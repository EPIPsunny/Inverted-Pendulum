# Keil uVision project 0LED_MK.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE;..\MKFILE\KEY;..\MKFILE\OLED;..\MKFILE;..\MKFILE\SOLGUI\Font;..\MKFILE\SOLGUI;..\MKFILE\TIMER;..\MKFILE\LED;..\MKFILE\LED;..\MKFILE\STMFLASH;..\MKFILE\PWM;..\MKFILE\USART3;..\MKFILE\niming;..\MKFILE\MPU6050\eMPL;..\MKFILE\MPU6050;..\MKFILE\CONTROL;..\MKFILE\ENCODER;..\MKFILE\WIFI;..\SYSTEM\usart;..\MKFILE\MPUEXTI;..\MKFILE\ADC;..\MKFILE\TEST
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c
  group HARDWARE
    ../MKFILE/: menu.c zimo.h
    ../MKFILE/OLED/: oled.c
    ../MKFILE/LED/: led.c
    ../MKFILE/STMFLASH/: stmflash.c
    ../MKFILE/CONTROL/: control.c
    ../MKFILE/ENCODER/: encoder.c
    ../MKFILE/WIFI/: wifi.c
    ../MKFILE/MPUEXTI/: mpuexti.c
    ../MKFILE/TIMER/: timer.c
    ../MKFILE/ADC/: adc.c
    ../MKFILE/TEST/: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_adc.c
  group README
    ../: README.TXT
  group SOUGUI
    ../MKFILE/SOLGUI/Font/: Font4x6_ASCII.c Font6x8_ASCII.c Font8x8_ASCII.c Font8x10_ASCII.c
    ../MKFILE/SOLGUI/: SOLGUI_Common.c SOLGUI_GBasic.c SOLGUI_Hardware.c SOLGUI_Menu.c SOLGUI_Picture.c SOLGUI_Printf.c SOLGUI_Widget.c
  group mpu6050
    ../MKFILE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MKFILE/MPU6050/: mpu6050.c mpuiic.c
software components: Device:Startup 1.0.0
